FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-SD-card-booting-setup.patch"
